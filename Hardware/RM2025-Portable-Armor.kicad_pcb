# Repository hkustenterprize/RM2025-Portable-Armor

File README.md:

# 低成本,高仿真手持装甲板
3D打印,低成本,高仿真手持装甲板. CV 调试用, 不可击打.

如图左为官方装甲板, 右图为我们自己的 3D 打印装甲板, 其亮度颜色形状高度一致.

## 硬件

> 灯珠与驱动板采用拼板设计. 可在 JLC 免费打样.

**硬件选型**
|部件|型号||
|:--|:--|:--|
|锂电池充电管理|IP2315|1s 锂电池快充|
|红蓝LED|3528红蓝双色交叉异极|与官方一致|
|开关|2.54mm 扭子开关 3 弯脚 3 档|

我们实测发现 IP5306, IP5407 等常见的电池充放电管理芯片静态功耗高. 对于几百 mAh 的小锂电池, 一两个星期就漏电漏完了. 故选择 IP2315 1S 锂电池快充芯片, 请根据锂电池容量大小调整充电电流配置电阻. 1C 为宜.
实测锂电池电压波动对亮度影响较小, 始终与官方装甲板亮度保持一致.

灯板排布, 灯珠选型, 灯板引脚定义都与官方装甲板一致. 本方案能较好模拟灯珠颗粒感. 

**焊接指南**
焊接时需要去掉 Type-c 插座的定位塑料柱. 扭子开关需去掉固定柱, 焊接在 3P 排针焊盘. Type-C, 扭子开关为易损件, 请打紫外胶固定.

## 机械
灯罩请使用白色 PETG 打印. 本体使用黑色 PETG. 铜螺母尺寸请按需修改.
./Mechanics/Production 文件夹下的文件可直接打印/切板

## KiCad design Hardware/RM2025-Portable-Armor.kicad_pcb

Parts:
C1: 10u; C_1206_3216Metric
C2, C3, C4, C6, C7, C8, C9: 10u; C_0805_2012Metric
C5: 100n; C_0603_1608Metric
D1: SS34; D_SMA
D2, D3: LED_Pink; LED_0603_1608Metric
D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25: LED_RB; LED_Avago_PLCC4_3.2x2.8mm_CW
F1: 1A; Fuse_1206_3216Metric
H1, H2, H3, H4: M1.6; M1.6_Small
H5, H6: M3; MountingHole_3.2mm_M3_Pad_Via
J1, J3, J5, J7: Armor; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
J6: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12_NO_HOLE
L1: 2u2; L_Sunlord_MWSA0603S
R1: 20; R_1206_3216Metric
R2: 180k; R_0603_1608Metric
R3: 51k; R_0603_1608Metric
R4: 200R; R_0603_1608Metric
R5, R6: 10k; R_0603_1608Metric
R7: NC; R_0603_1608Metric
SW1: SW_SPDT; PinHeader_1x03_P2.54mm_Horizontal
TP1: VBAT; TestPoint_Pad_2.0x2.0mm
TP2: GND; TestPoint_Pad_2.0x2.0mm
U1: IP2315; QFN-32-1EP_5x5mm_P0.5mm_EP3.6x3.6mm

Connections:
/BLUE: D4.4 (K2), D5.4 (K2), D6.4 (K2), D7.4 (K2), D8.4 (K2), D9.4 (K2), D10.4 (K2), D11.4 (K2), D12.4 (K2), D13.4 (K2), D14.4 (K2), D15.4 (K2), D16.4 (K2), D17.4 (K2), D18.4 (K2), D19.4 (K2), D20.4 (K2), D21.4 (K2), D22.4 (K2), D23.4 (K2), D24.4 (K2), D25.4 (K2), J1.2, J3.2, J5.2, J7.2, SW1.3 (C)
/CC1: J6.A5 (CC1), U1.2 (CC1)
/CC2: J6.B5 (CC2), U1.3 (CC2)
/DMC: J6.A7 (D-), J6.B7 (D-), U1.23 (DM)
/DPC: J6.A6 (D+), J6.B6 (D+), U1.24 (DP)
/HLED: R4.2, U1.16 (HLED)
/ICHGSET: R2.1, U1.27 (ICHGSET)
/LED1: D2.2 (A), R5.1, U1.8 (LED1)
/LED2: R6.1, U1.9 (LED2)
/LED3: R7.1, U1.10 (LED3)
/NTC: R3.1, U1.26 (NTC)
/RED: D4.2 (K1), D5.2 (K1), D6.2 (K1), D7.2 (K1), D8.2 (K1), D9.2 (K1), D10.2 (K1), D11.2 (K1), D12.2 (K1), D13.2 (K1), D14.2 (K1), D15.2 (K1), D16.2 (K1), D17.2 (K1), D18.2 (K1), D19.2 (K1), D20.2 (K1), D21.2 (K1), D22.2 (K1), D23.2 (K1), D24.2 (K1), D25.2 (K1), J1.1, J3.1, J5.1, J7.1, SW1.1 (A)
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, D1.2 (A), D2.1 (K), D3.1 (K), D4.1 (A1), D4.3 (A2), D5.1 (A1), D5.3 (A2), D6.1 (A1), D6.3 (A2), D7.1 (A1), D7.3 (A2), D8.1 (A1), D8.3 (A2), D9.1 (A1), D9.3 (A2), D10.1 (A1), D10.3 (A2), D11.1 (A1), D11.3 (A2), D12.1 (A1), D12.3 (A2), D13.1 (A1), D13.3 (A2), D14.1 (A1), D14.3 (A2), D15.1 (A1), D15.3 (A2), D16.1 (A1), D16.3 (A2), D17.1 (A1), D17.3 (A2), D18.1 (A1), D18.3 (A2), D19.1 (A1), D19.3 (A2), D20.1 (A1), D20.3 (A2), D21.1 (A1), D21.3 (A2), D22.1 (A1), D22.3 (A2), D23.1 (A1), D23.3 (A2), D24.1 (A1), D24.3 (A2), D25.1 (A1), D25.3 (A2), H5.1, H6.1, J1.3, J1.4, J1.MP (MountPin), J3.3, J3.4, J3.MP (MountPin), J5.3, J5.4, J5.MP (MountPin), J6.A1 (GND), J6.A12 (GND), J6.B1 (GND), J6.B12 (GND), J6.S1 (SHIELD), J7.3, J7.4, J7.MP (MountPin), R2.2, R3.2, R5.2, R6.2, R7.2, TP2.1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
unnamed: C2.1, C3.1, C4.1, C6.1, U1.6 (VSYS), U1.7 (VSYS), U1.18 (VSYS), U1.19 (VSYS)
unnamed: C5.2, D1.1 (K), L1.1, U1.11 (LX), U1.12 (LX), U1.13 (LX), U1.14 (LX)
unnamed: D3.2 (A), R4.1
unnamed: F1.2, J6.A4 (VBUS), J6.A9 (VBUS), J6.B4 (VBUS), J6.B9 (VBUS)
unnamed: R1.2, SW1.2 (B)
unnamed: C5.1, U1.15 (BST)
VBAT: C7.1, C8.1, C9.1, L1.2, R1.1, TP1.1, U1.22 (BAT)
VIN_5V: C1.1, F1.1, U1.20 (VIN), U1.21 (VIN)

Notes on the sheet:
VBAT_SEL: 4.2V
快充指示灯
ICHG: 1.5A

Board: 2 copper layers, 46.2 x 48.5 mm, 58 parts (12 on the bottom side), 21 nets.

## Commit log

2025-08-17 Open Source
